File: kicad/svgtest/svgtest.kicad_pcb (KiCad board)
At the start: 2 copper layers, 0 parts

Commit message: lol
Other:
- board outline added: 134.2 x 118.9 mm
